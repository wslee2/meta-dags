DESCRIPTION = "meta file for enigma2 softcam config packages"

require conf/license/openpli-gplv2.inc

PROVIDES = "softcams"

DEPENDS = "\
           enigma2-plugin-softcams-cccam-config \
           enigma2-plugin-softcams-newcs-config \
           "   
