do_install_append() {
    ln -s /etc/tuxbox/ ${D}/var/
}
